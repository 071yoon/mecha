# IAR project Mecha_Final.ewp, settings and files
configuration Mecha_Final (ARM, debug)
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa050,Pa084,Pa093,Pa082
  ICCARM.IExtraOptions: -DDEVICE_ANALOGOUT=1; -DMBED_TRAP_ERRORS_ENABLED=1; -DDEVICE_SERIAL_FC=1; -DMBED_BUILD_TIMESTAMP=1616775333.3018234; -DDEVICE_ANALOGIN=1; -D__MBED__=1; --diag_suppress=Pa050,Pa084,Pa093,Pa082,Pe540; -DTOOLCHAIN_IAR; -DDEVICE_WATCHDOG=1; -D__CORTEX_M3; -DDEVICE_SLEEP=1; -DARM_MATH_CM3; -DDEVICE_PORTOUT=1; -DDEVICE_CAN=1; -DDEVICE_PORTINOUT=1; --no_wrap_diagnostics; -DDEVICE_PORTIN=1; -DDEVICE_STDIO_MESSAGES=1; -DTARGET_NXP_EMAC; -DTARGET_LIKE_CORTEX_M3; -DDEVICE_DEBUG_AWARENESS=1; -DDEVICE_MPU=1; -DMBED_RAM1_SIZE=0x8000; -DDEVICE_FLASH=1; -DTARGET_LPC176X; -DDEVICE_PWMOUT=1; -DTARGET_NXP; -DDEVICE_INTERRUPTIN=1; -D__MBED_CMSIS_RTOS_CM; --preinclude=mbed_config.h; -DDEVICE_EMAC=1; -DTARGET_MBED_LPC1768; -DMBED_RAM_START=0x10000000; -DMBED_RAM1_START=0x2007c000; -DMBED_MINIMAL_PRINTF; -DTARGET_NAME=LPC1768; -DMBED_ROM_START=0x0; -D__CMSIS_RTOS; -DTARGET_LPC1768; -DDEVICE_SPI=1; -DDEVICE_LOCALFILESYSTEM=1; -DTARGET_LPCTarget; -DTARGET_CORTEX; -DDEVICE_RTC=1; --diag_suppress=Pe546; -DDEVICE_SPISLAVE=1; -DTARGET_M3; --guard_calls; -DDEVICE_RESET_REASON=1; -DDEVICE_USTICKER=1; -DDEVICE_USBDEVICE=1; -DDEVICE_I2CSLAVE=1; -e; -DDEVICE_SEMIHOST=1; --enable_restrict; -DTARGET_RELEASE; -DMBED_RAM_SIZE=0x8000; -DDEVICE_SERIAL=1; -DMBED_ROM_SIZE=0x80000; -DDEVICE_ETHERNET=1; -DTARGET_CORTEX_M; -DTARGET_LIKE_MBED; -DDEVICE_I2C=1
  ICCARM.CCIncludePath2: ; /usr/src/mbed-sdk; Actuator; Plotting; Sensor; mbed; mbed/TARGET_LPC1768/TOOLCHAIN_IAR; mbed/drivers; mbed/hal; mbed/platform
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AExtraOptionsV2: -DARM_MATH_CM3; -D__CMSIS_RTOS; -D__CORTEX_M3; -D__MBED_CMSIS_RTOS_CM; "-DMBED_CONF_TARGET_CONSOLE_UART=1"; "-DMBED_CONF_TARGET_NETWORK_DEFAULT_INTERFACE_TYPE=ETHERNET"; "-DMBED_CONF_TARGET_DEEP_SLEEP_LATENCY=0"; "-DMBED_CONF_TARGET_BOOT_STACK_SIZE=0x1000"; "-DMBED_CONF_TARGET_MPU_ROM_END=0x0fffffff"; "-DMBED_CONF_TARGET_TICKLESS_FROM_US_TICKER=0"; "-DMBED_CONF_TARGET_INIT_US_TICKER_AT_BOOT=0"; "-DMBED_CONF_TARGET_XIP_ENABLE=0"; "-DMBED_CONF_TARGET_DEFAULT_ADC_VREF=NAN"; "-DMBED_CONF_TARGET_US_TICKER_TIMER=3"; "-DMBED_CONF_PLATFORM_STDIO_CONVERT_NEWLINES=0"; "-DMBED_CONF_PLATFORM_STDIO_CONVERT_TTY_NEWLINES=0"; "-DMBED_CONF_PLATFORM_STDIO_BUFFERED_SERIAL=0"; "-DMBED_CONF_PLATFORM_STDIO_BAUD_RATE=9600"; "-DMBED_CONF_PLATFORM_STDIO_FLUSH_AT_EXIT=1"; "-DMBED_CONF_PLATFORM_DEFAULT_SERIAL_BAUD_RATE=9600"; "-DMBED_CONF_PLATFORM_FORCE_NON_COPYABLE_ERROR=0"; "-DMBED_CONF_PLATFORM_POLL_USE_LOWPOWER_TIMER=0"; "-DMBED_CONF_PLATFORM_ERROR_HIST_ENABLED=0"; "-DMBED_CONF_PLATFORM_ERROR_HIST_SIZE=4"; "-DMBED_CONF_PLATFORM_ERROR_FILENAME_CAPTURE_ENABLED=0"; "-DMBED_CONF_PLATFORM_ERROR_ALL_THREADS_INFO=0"; "-DMBED_CONF_PLATFORM_MAX_ERROR_FILENAME_LEN=16"; "-DMBED_CONF_PLATFORM_CTHUNK_COUNT_MAX=8"; "-DMBED_CONF_PLATFORM_CRASH_CAPTURE_ENABLED=0"; "-DMBED_CONF_PLATFORM_ERROR_REBOOT_MAX=1"; "-DMBED_CONF_PLATFORM_FATAL_ERROR_AUTO_REBOOT_ENABLED=0"; "-DMBED_CONF_PLATFORM_USE_MPU=1"
  OBJCOPY.OOCOutputFile: name.srec
  ILINK.IlinkOutputFile: name.out
  ILINK.IlinkIcfFile: mbed/TARGET_LPC1768/TOOLCHAIN_IAR/LPC17xx.icf
  ILINK.IlinkExtraOptions: --skip_dynamic_initialization; --threaded_lib; --inline; --config_def MBED_ROM_START=0x0; --config_def MBED_ROM_SIZE=0x80000; --config_def MBED_RAM_START=0x10000000; --config_def MBED_RAM_SIZE=0x8000; --config_def MBED_RAM1_START=0x2007c000; --config_def MBED_RAM1_SIZE=0x8000; --config_def MBED_BOOT_STACK_SIZE=4096; --config_def XIP_ENABLE=0
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Actuator
    Actuator/: Motor.h Servo.h Motor.cpp Servo.cpp
  group Mecha_Final
    ./: mbed_config.h main.cpp
  group Plotting
    Plotting/: Plotting.h Plotting.cpp
  group Sensor
    Sensor/: DistanceSensor.h LaneSensor.h DistanceSensor.cpp LaneSensor.cpp
  group mbed
    mbed/TARGET_LPC1768/TOOLCHAIN_IAR/: LPC17xx.h PeripheralNames.h PinNames.h PortNames.h RTE_Components.h arm_math.h cmsis.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_nvic.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_sc000.h core_sc300.h device.h gpio_object.h mbed_cmsis_conf.h mbed_fault_handler.h mbed_rtx.h mpu_armv7.h mpu_armv8.h objects.h reserved_pins.h system_LPC17xx.h tz_context.h CRP.o analogin_api.o analogout_api.o can_api.o cmain.o ethernet_api.o except.o flash_api.o gpio_api.o gpio_irq_api.o i2c_api.o mbed_board.o mbed_fault_handler.o mbed_retarget.o mbed_sdk_boot.o mbed_tz_context.o pinmap.o port_api.o pwmout_api.o rtc_api.o serial_api.o sleep.o spi_api.o startup_LPC17xx.o system_LPC17xx.o us_ticker.o mbed.a
    mbed/drivers/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h Ethernet.h FlashIAP.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h MbedCRC.h PortIn.h PortInOut.h PortOut.h PwmOut.h QSPI.h RawSerial.h SPI.h SPISlave.h Serial.h SerialBase.h SerialWireOutput.h TableCRC.h Ticker.h Timeout.h Timer.h TimerEvent.h UARTSerial.h
    mbed/hal/: Driver_Common.h Driver_Storage.h LowPowerTickerWrapper.h analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h crc_api.h critical_section_api.h dma_api.h ethernet_api.h flash_api.h flash_data.h gpio_api.h gpio_irq_api.h i2c_api.h itm_api.h lp_ticker_api.h mbed_lp_ticker_wrapper.h mpu_api.h pinmap.h port_api.h pwmout_api.h qspi_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h spm_api.h ticker_api.h trng_api.h us_ticker_api.h
    mbed/: mbed.h
    mbed/platform/: ATCmdParser.h CThunk.h CThunkBase.h CallChain.h Callback.h CircularBuffer.h CriticalSectionLock.h DeepSleepLock.h DirHandle.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemHandle.h FileSystemLike.h FunctionPointer.h LocalFileSystem.h NonCopyable.h PlatformMutex.h ScopedLock.h ScopedRamExecutionLock.h ScopedRomWriteLock.h SharedPtr.h SingletonPtr.h Span.h Stream.h Transaction.h critical.h mbed_application.h mbed_assert.h mbed_crash_data_offsets.h mbed_critical.h mbed_debug.h mbed_error.h mbed_error_hist.h mbed_interface.h mbed_mem_trace.h mbed_mktime.h mbed_mpu_mgmt.h mbed_poll.h mbed_power_mgmt.h mbed_preprocessor.h mbed_retarget.h mbed_rtc_time.h mbed_semihost_api.h mbed_sleep.h mbed_stats.h mbed_toolchain.h mbed_version.h mbed_wait_api.h platform.h rtc_time.h semihost_api.h sleep.h toolchain.h wait_api.h
